# Keil uVision project RationUART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114LVFHI33/303 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RationUART +hex
  c flags: Optim=1
  c include: .\CFG;.\LPC11XX;.\User
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC11xx.s
  group LPC11XX
    ./LPC11XX/: system_LPC11xx.c
  group User
    ./User/: main.c event.c queue.c ctrl.c led.c
  group CFG
    ./CFG/: uart.c
software components: CMSIS:CORE 4.1.0
